#include "rating.h"

#define STAR 20      /* size of the drawn star */
#define LABEL_GAP 8

/* A 20x20 star as a 4-bit coverage mask, made by tools/gen_star.py. */
static const uint8_t star_mask[200] = {
    0x00, 0x00, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x05, 0x50, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x0A, 0xA0, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x1F, 0xF1, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x5F, 0xF5, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0xAF, 0xFA, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0x00,
    0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x70,
    0x00, 0x4D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xD4, 0x00,
    0x00, 0x01, 0xAF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFA, 0x10, 0x00,
    0x00, 0x00, 0x06, 0xEF, 0xFF, 0xFF, 0xFE, 0x60, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x9F, 0xFF, 0xFF, 0xF9, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x04, 0xFF, 0xFE, 0xEF, 0xFF, 0x40, 0x00, 0x00,
    0x00, 0x00, 0x09, 0xFF, 0xB2, 0x2B, 0xFF, 0x90, 0x00, 0x00,
    0x00, 0x00, 0x0D, 0xF7, 0x00, 0x00, 0x7F, 0xD0, 0x00, 0x00,
    0x00, 0x00, 0x4D, 0x30, 0x00, 0x00, 0x03, 0xD4, 0x00, 0x00,
    0x00, 0x00, 0x41, 0x00, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};

bool rating(cydui_ui *ui, const char *label, int *value)
{
    cydui_mods m;
    const cydui_style *st;
    cydui_id id;
    cydui_text_extent e;
    cydui_response resp;
    cydui_rect r, area;
    cydui_color on, off;
    size_t n;
    int target, label_w, h, v, i;
    bool changed = false;

    if (!cydui_widget_begin(ui)) {
        return false;
    }
    m = cydui_take_mods(ui);
    st = &cydui_theme_of(ui)->style;
    label = label ? label : "";
    id = cydui_id_str(ui, label);
    cydui_id_claim(ui, id);

    n = cydui_label_len(label);
    e = cydui_text_size(st->font, label, n, 0);
    target = st->min_target > STAR ? st->min_target : STAR;
    label_w = n ? e.w + LABEL_GAP : 0;
    h = target > e.h ? target : e.h;
    r = cydui_alloc(ui, &m, label_w + RATING_STARS * target, h);

    area.x = (int16_t)(r.x + label_w);
    area.y = r.y;
    area.w = (int16_t)(RATING_STARS * target);
    area.h = r.h;

    v = value ? *value : 0;
    v = v < 0 ? 0 : (v > RATING_STARS ? RATING_STARS : v);
    resp = cydui_interact(ui, id, area, CYDUI_SENSE_CLICK | (m.disabled ? CYDUI_DISABLED : 0u));
    if (resp.clicked) {
        i = (resp.x - area.x) / target; /* the star under the finger when it let go: 0..4, as the tap was inside */
        v = v == i + 1 ? 0 : i + 1; /* the last lit star again clears */
        changed = true;
    }
    if (value) {
        *value = v;
    }

    on = st->accent;
    off = st->border;
    if (m.disabled) {
        on = cydui_blend(st->bg, on, 110);
        off = cydui_blend(st->bg, off, 110);
    }
    for (i = 0; i < RATING_STARS; i++) {
        cydui_rect s;
        s.x = (int16_t)(area.x + i * target + (target - STAR) / 2);
        s.y = (int16_t)(area.y + (area.h - STAR) / 2);
        s.w = s.h = STAR;
        cydui_draw_bitmap(&ui->ctx, s, star_mask, sizeof(star_mask), CYDUI_BITMAP_A4, i < v ? on : off, 255);
    }
    if (n) {
        cydui_draw_text_in(ui, r, r.x, r.y + (r.h - e.h) / 2, label, n, m.disabled ? st->text_muted : st->text);
    }
    return changed;
}
